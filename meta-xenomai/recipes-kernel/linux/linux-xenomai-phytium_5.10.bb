require linux-xenomai.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
KERNEL_BRANCH ?= "master"
SRCREV = "62cf5c5a20fd07d0e39b76f293237193dd6b3058"
