COMPATIBLE_HOST = ".*-linux"
