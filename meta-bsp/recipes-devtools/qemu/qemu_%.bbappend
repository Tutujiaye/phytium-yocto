PACKAGECONFIG:append = " libusb"
