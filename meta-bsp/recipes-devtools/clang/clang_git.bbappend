SYSROOT_PREPROCESS_FUNCS_remove_class-target = " clang_sysroot_preprocess"
