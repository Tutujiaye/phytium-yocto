LLVM_GIT = "git://mirrors.tuna.tsinghua.edu.cn/git"
