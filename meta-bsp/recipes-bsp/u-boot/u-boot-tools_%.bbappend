SRC_URI = "git://gitee.com/mirrors/u-boot.git;protocol=https;branch=master"
