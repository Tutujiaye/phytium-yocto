pkg_postinst_ontarget_${PN} () {
# run this on the target
}

