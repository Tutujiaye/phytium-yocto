RDEPENDS_${PN} = "initramfs-framework-base grub-efi parted e2fsprogs-mke2fs util-linux-blkid ${VIRTUAL-RUNTIME_base-utils}"
