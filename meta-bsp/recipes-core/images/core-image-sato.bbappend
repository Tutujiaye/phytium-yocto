IMAGE_INSTALL:append = " \
    mesa-demos \
    x11perf \
    glmark2 \
    xserver-nodm-init \
"

