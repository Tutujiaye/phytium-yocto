PRETTY_NAME="Phytium Linux (Core) dracut-049-70.git20200228.el8 (Initramfs)"
