FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://0001-pyanaconda-fix-install-issue.patch"

