EXTRA_OECONF += "--enable-glamor"
