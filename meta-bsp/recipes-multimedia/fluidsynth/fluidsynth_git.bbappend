SRC_URI = "git://github.com/FluidSynth/fluidsynth.git;branch=master;protocol=https"
