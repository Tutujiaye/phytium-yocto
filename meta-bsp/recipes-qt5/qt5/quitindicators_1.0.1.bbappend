INSANE_SKIP_${PN} += "useless-rpaths"
