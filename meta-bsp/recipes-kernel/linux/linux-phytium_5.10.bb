require linux-phytium.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
KERNEL_BRANCH = "linux-5.10"

SRCREV = "0113bee49ab9812b962b636618332f421b6d9528"

