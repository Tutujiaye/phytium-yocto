require linux-phytium.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bbea815ee2795b2f4230826c0c6b8814"
KERNEL_BRANCH = "linux-4.19"

SRCREV = "401e9f41830447312181b43864b22a2a61d8dd27"
