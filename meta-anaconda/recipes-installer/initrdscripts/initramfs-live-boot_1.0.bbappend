FILESEXTRAPATHS_append_anaconda := ":${THISDIR}/files"

SRC_URI_append_anaconda = " \
    file://init-live.sh \
"
