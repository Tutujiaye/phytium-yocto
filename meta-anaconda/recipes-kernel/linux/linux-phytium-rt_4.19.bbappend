DELTA_KERNEL_DEFCONFIG_anaconda = " iso.config"
DELTA_KERNEL_DEFCONFIG = " iso.config"
