FILESEXTRAPATHS_prepend := "${THISDIR}/lvm2:"

SRC_URI += "file://lvm.conf"
